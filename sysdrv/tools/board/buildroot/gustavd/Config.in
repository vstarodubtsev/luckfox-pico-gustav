## sysdrv/tools/board/buildroot/gustavd/Config.in
```kconfig
config BR2_PACKAGE_GUSTAVD
	bool "gustavd"
	help
	  gustavd daemon.

	  https://github.com/vstarodubtsev/gustavd
```
